FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-tools-Fix-build-after-y2038-changes-in-glibc.patch"
